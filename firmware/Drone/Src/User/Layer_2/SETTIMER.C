///// INCLUDES ////////////////////////////////////////////////////////////////
#include "headers.h"


///// VARIABLES ///////////////////////////////////////////////////////////////
volatile TIMER  Timer[TID_LAST];


/******************************************************************************
// 역할 : 소프트웨어 타이머 슬롯을 초기화한다.
// 매개 :
// 반환 :
// 주의 :
******************************************************************************/

void Init_SetTimer(void)
{   
    unsigned int    i;
    for(i=0;i<TID_LAST;i++) {        
    	Timer[i].wCount=0x0000;
        Timer[i].bFinished = 0;
    }   
}
/******************************************************************************
// 역할 : 지정한 ID의 소프트웨어 타이머를 시작한다.
// 매개 : ID - 타이머 ID, Interval - 타이머 주기, func - 완료 시 호출 함수
// 반환 :
// 주의 :
******************************************************************************/
void SetTimer(unsigned int ID, unsigned int Interval, void (*func)(void))
{
    Timer[ID].wCount = Interval;
    Timer[ID].bFinished = 0;
    Timer[ID].func = func;
}
/******************************************************************************
// 역할 : 지정한 ID의 소프트웨어 타이머를 중지한다.
// 매개 : ID - 타이머 ID
// 반환 :
// 주의 :
******************************************************************************/

void KillTimer(unsigned int ID)
{
	Timer[ID].wCount = 0;
	Timer[ID].bFinished = 0;
}


/******************************************************************************
// 역할 : 10msec 주기로 타이머를 감소시키고 완료 플래그를 설정한다.
// 매개 :
// 반환 :
// 주의 :
******************************************************************************/
void SetTimer_Finish_Time(void)
{   
    unsigned int    i;
    for(i=0;i<TID_LAST;i++) {        
        if(Timer[i].wCount!=0) {
            Timer[i].wCount-=1;
            if(Timer[i].wCount==0) {	        // 카운트가 0이 되면
                Timer[i].bFinished = 1;		    // 완료 플래그 설정
            }
        }
    }   
}
/******************************************************************************
// 역할 : 완료된 타이머의 콜백 함수를 호출한다.
// 매개 :
// 반환 :
// 주의 :
******************************************************************************/
void SetTimer_Check(void)
{
    unsigned int i;
    for(i=0;i<TID_LAST;i++) {
        if(Timer[i].bFinished == 1) {
            Timer[i].bFinished = 0;
            Timer[i].func();
        }
    }
}
